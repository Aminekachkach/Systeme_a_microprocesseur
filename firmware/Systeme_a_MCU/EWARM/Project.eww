<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Systeme_a_MCU.ewp</path>
  </project>
  <batchBuild />
</workspace>
